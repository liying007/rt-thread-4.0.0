# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx, LFS_CONFIG=lfs_config.h, RT_USING_ARM_LIBC
  c include: .;..\..\..\include;applications;.;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\libraries\HAL_Drivers\drv_flash;packages\cJSON-latest;packages\fal-latest\inc;packages\filesystem_samples-v0.2.0;packages\littlefs-latest;packages\LittlevGL2RTT-latest;packages\LittlevGL2RTT-latest\lvgl;packages\LittlevGL2RTT-latest\lvgl\lv_core;packages\LittlevGL2RTT-latest\lvgl\lv_draw;packages\LittlevGL2RTT-latest\lvgl\lv_hal;packages\LittlevGL2RTT-latest\lvgl\lv_misc;packages\LittlevGL2RTT-latest\lvgl\lv_fonts;packages\LittlevGL2RTT-latest\lvgl\lv_objx;packages\LittlevGL2RTT-latest\lvgl\lv_themes;packages\LittlevGL2RTT-latest\lvgl\lv_porting;packages\mpu6xxx-latest\inc;packages\sqlite-v3.19.3;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\cplusplus;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\drivers\audio;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\usb\usbdevice;..\..\..\components\drivers\usb\usbhost;..\..\..\components\drivers\usb\usbhost\class;..\..\..\components\drivers\usb\usbhost\core;..\..\..\components\drivers\usb\usbhost\include;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\utilities\logtrace;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_HAL\CMSIS\Include;.\applications\key;.\applications\led;.\applications\public;.\applications\tftlcd
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group Kernel
    ../../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: app_uart.c main.c
    applications/tftlcd/: tftlcd.c
    applications/public/: stm32f4xx_fsmc.c gpio.c
    applications/key/: key.c
    applications/led/: led.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/ports/: spi_flash_init.c sdcard_port.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_spi.c drv_usb.c drv_soft_i2c.c drv_adc.c drv_rtc.c drv_wdt.c drv_sdio.c drv_common.c
    ../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group cJSON
    packages/cJSON-latest/: cJSON.c cJSON_port.c cJSON_util.c
  group fal
    packages/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group filesystem-samples
    packages/filesystem_samples-v0.2.0/: readwrite_sample.c
  group littlefs
    packages/littlefs-latest/: dfs_lfs.c lfs.c lfs_crc.c lfs_util.c
  group LittlevGL2RTT
    packages/LittlevGL2RTT-latest/: littlevgl2rtt.c
    packages/LittlevGL2RTT-latest/lvgl/lv_core/: lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_vdb.c
    packages/LittlevGL2RTT-latest/lvgl/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rbasic.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vbasic.c
    packages/LittlevGL2RTT-latest/lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    packages/LittlevGL2RTT-latest/lvgl/lv_misc/: lv_anim.c lv_area.c lv_circ.c lv_color.c lv_font.c lv_fs.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_ufs.c
    packages/LittlevGL2RTT-latest/lvgl/lv_fonts/: lv_font_builtin.c lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_monospace_8.c lv_font_simfang.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c
    packages/LittlevGL2RTT-latest/lvgl/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_sw.c lv_ta.c lv_tabview.c lv_win.c
    packages/LittlevGL2RTT-latest/lvgl/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
    packages/LittlevGL2RTT-latest/lvgl/lv_porting/: lv_port_disp.c
  group mpu6xxx
    packages/mpu6xxx-latest/src/: mpu6xxx.c
  group sqlite
    packages/sqlite-v3.19.3/: sqlite3.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group CPlusPlus
    ../../../components/cplusplus/: Mutex.cpp Semaphore.cpp Thread.cpp crt.cpp crt_init.c
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../../components/drivers/audio/: audio.c audio_pipe.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c adc.c
    ../../../components/drivers/mtd/: mtd_nor.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_w25qxx.c spi_msd.c spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/watchdog/: watchdog.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/core/: core.c usbdevice.c
    ../../../components/drivers/usb/usbdevice/class/: cdc_vcom.c hid.c mstorage.c winusb.c
  group rt_usbh
    ../../../components/drivers/usb/usbhost/core/: core.c driver.c usbhost.c hub.c
    ../../../components/drivers/usb/usbhost/class/: mass.c udisk.c
  group finsh
    ../../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../../components/libc/compilers/common/: gmtime_r.c
  group Utilities
    ../../../components/utilities/logtrace/: log_trace.c log_file.c
  group STM32_HAL
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
